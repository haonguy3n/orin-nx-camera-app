require recipes-bsp/uefi/edk2-basetools-gcc-compat.inc
